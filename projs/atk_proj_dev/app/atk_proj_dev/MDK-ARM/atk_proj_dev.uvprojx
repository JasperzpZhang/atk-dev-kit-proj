# Keil uVision project atk_proj_dev.uvprojx, settings and files
target atk_proj_dev (5060960::V5.06 update 7 (build 960)::.\ARM_Complier_5.06)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: atk_proj_dev +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/STM32F1xx_HAL_Driver/Inc;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../../src/arm;..\..\src\arm\lib;..\..\src\arm\lib\lvgl;..\..\src\arm\lib\lvgl\src;..\..\src\arm\lib\lvgl\examples\porting;..\..\src\arm\app\svc\lvgl;..\..\src\arm\app\svc\lvgl\images;..\..\src\arm\app\svc\lvgl\guider_fonts;..\..\src\arm\app\svc\lvgl\guider_customer_fonts;..\..\src\arm\app\svc\lvgl\custom
  asm include: ../Core/Inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c dma.c fsmc.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c stm32f1xx_hal_timebase_tim.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_ll_fsmc.c stm32f1xx_hal_sram.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
  group lib
    ../../src/arm/lib/uart/: lib_uart.c
    ../../src/arm/lib/debug/: lib_debug.c lib_debug_uart.c
    ../../src/arm/lib/cli/: lib_cli.c lib_cli_custom.c
    ../../src/arm/lib/delay/: lib_delay.c
    ../../src/arm/lib/sys/: lib_sys.c
    ../../src/arm/lib/i2c/: lib_i2c.c
  group drv
    ../../src/arm/drv/peri/sc/: drv_sc.c drv_lcd.c drv_tp.c drv_tp_ft5206.c drv_tp_gt9xxx.c drv_tp_ctiic.c
    ../../src/arm/drv/peri/eeprom/: drv_24cxx.c
  group app
    ../../src/arm/app/: app.c sys.c
    ../../src/arm/app/svc/: cli.c sc.c
  group lvgl
    ../../src/arm/lib/lvgl/examples/porting/: lv_port_disp.c lv_port_indev.c
    ../../src/arm/lib/lvgl/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
    ../../src/arm/lib/lvgl/src/draw/arm2d/: lv_gpu_arm2d.c
    ../../src/arm/lib/lvgl/src/draw/nxp/pxp/: lv_draw_pxp.c lv_draw_pxp_blend.c lv_gpu_nxp_pxp.c lv_gpu_nxp_pxp_osa.c
    ../../src/arm/lib/lvgl/src/draw/nxp/vglite/: lv_draw_vglite.c lv_draw_vglite_arc.c lv_draw_vglite_blend.c lv_draw_vglite_line.c lv_draw_vglite_rect.c lv_vglite_buf.c lv_vglite_utils.c
    ../../src/arm/lib/lvgl/src/draw/renesas/: lv_gpu_d2_draw_label.c lv_gpu_d2_ra6m3.c
    ../../src/arm/lib/lvgl/src/draw/sdl/: lv_draw_sdl.c lv_draw_sdl_arc.c lv_draw_sdl_bg.c lv_draw_sdl_composite.c lv_draw_sdl_img.c lv_draw_sdl_label.c lv_draw_sdl_layer.c lv_draw_sdl_line.c lv_draw_sdl_mask.c lv_draw_sdl_polygon.c lv_draw_sdl_rect.c lv_draw_sdl_stack_blur.c lv_draw_sdl_texture_cache.c lv_draw_sdl_utils.c
    ../../src/arm/lib/lvgl/src/draw/stm32_dma2d/: lv_gpu_stm32_dma2d.c
    ../../src/arm/lib/lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_layer.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c lv_draw_sw_transform.c
    ../../src/arm/lib/lvgl/src/draw/swm341_dma2d/: lv_gpu_swm341_dma2d.c
    ../../src/arm/lib/lvgl/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_layer.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_transform.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ../../src/arm/lib/lvgl/src/extra/layouts/flex/: lv_flex.c
    ../../src/arm/lib/lvgl/src/extra/layouts/grid/: lv_grid.c
    ../../src/arm/lib/lvgl/src/extra/libs/bmp/: lv_bmp.c
    ../../src/arm/lib/lvgl/src/extra/libs/ffmpeg/: lv_ffmpeg.c
    ../../src/arm/lib/lvgl/src/extra/libs/freetype/: lv_freetype.c
    ../../src/arm/lib/lvgl/src/extra/libs/fsdrv/: lv_fs_fatfs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_win32.c
    ../../src/arm/lib/lvgl/src/extra/libs/gif/: gifdec.c lv_gif.c
    ../../src/arm/lib/lvgl/src/extra/libs/png/: lodepng.c lv_png.c
    ../../src/arm/lib/lvgl/src/extra/libs/qrcode/: lv_qrcode.c qrcodegen.c
    ../../src/arm/lib/lvgl/src/extra/libs/rlottie/: lv_rlottie.c
    ../../src/arm/lib/lvgl/src/extra/libs/sjpg/: lv_sjpg.c tjpgd.c
    ../../src/arm/lib/lvgl/src/extra/others/fragment/: lv_fragment.c lv_fragment_manager.c
    ../../src/arm/lib/lvgl/src/extra/others/gridnav/: lv_gridnav.c
    ../../src/arm/lib/lvgl/src/extra/others/ime/: lv_ime_pinyin.c
    ../../src/arm/lib/lvgl/src/extra/others/imgfont/: lv_imgfont.c
    ../../src/arm/lib/lvgl/src/extra/others/monkey/: lv_monkey.c
    ../../src/arm/lib/lvgl/src/extra/others/msg/: lv_msg.c
    ../../src/arm/lib/lvgl/src/extra/others/snapshot/: lv_snapshot.c
    ../../src/arm/lib/lvgl/src/extra/themes/basic/: lv_theme_basic.c
    ../../src/arm/lib/lvgl/src/extra/themes/default/: lv_theme_default.c
    ../../src/arm/lib/lvgl/src/extra/themes/mono/: lv_theme_mono.c
    ../../src/arm/lib/lvgl/src/extra/widgets/animimg/: lv_animimg.c
    ../../src/arm/lib/lvgl/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../../src/arm/lib/lvgl/src/extra/widgets/chart/: lv_chart.c
    ../../src/arm/lib/lvgl/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ../../src/arm/lib/lvgl/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ../../src/arm/lib/lvgl/src/extra/widgets/keyboard/: lv_keyboard.c
    ../../src/arm/lib/lvgl/src/extra/widgets/led/: lv_led.c
    ../../src/arm/lib/lvgl/src/extra/widgets/list/: lv_list.c
    ../../src/arm/lib/lvgl/src/extra/widgets/menu/: lv_menu.c
    ../../src/arm/lib/lvgl/src/extra/widgets/meter/: lv_meter.c
    ../../src/arm/lib/lvgl/src/extra/widgets/msgbox/: lv_msgbox.c
    ../../src/arm/lib/lvgl/src/extra/widgets/span/: lv_span.c
    ../../src/arm/lib/lvgl/src/extra/widgets/spinbox/: lv_spinbox.c
    ../../src/arm/lib/lvgl/src/extra/widgets/spinner/: lv_spinner.c
    ../../src/arm/lib/lvgl/src/extra/widgets/tabview/: lv_tabview.c
    ../../src/arm/lib/lvgl/src/extra/widgets/tileview/: lv_tileview.c
    ../../src/arm/lib/lvgl/src/extra/widgets/win/: lv_win.c
    ../../src/arm/lib/lvgl/src/extra/: lv_extra.c
    ../../src/arm/lib/lvgl/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
    ../../src/arm/lib/lvgl/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    ../../src/arm/lib/lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
    ../../src/arm/lib/lvgl/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
  group gui
    ../../src/arm/app/svc/lvgl/: setup_scr_sc_home.c gui_guider.c events_init.c widgets_init.c
    ../../src/arm/app/svc/lvgl/custom/: custom.c
software components: CMSIS:CORE 4.3.0
